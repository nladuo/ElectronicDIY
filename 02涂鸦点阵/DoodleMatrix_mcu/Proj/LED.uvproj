# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: LED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;..\My_Lib\delay;..\My_Lib\LED;..\My_Lib\matrix
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c
  group ST_Lib
    ../ST_Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
  group My_Lib
    ../My_Lib/LED/: led.c
    ../My_Lib/delay/: delay.c
  group System
    ../System/startup/: startup_stm32f0xx_ld.s
    ../System/CMSIS/: core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group Matrix
    ../My_Lib/matrix/: matrix.c
